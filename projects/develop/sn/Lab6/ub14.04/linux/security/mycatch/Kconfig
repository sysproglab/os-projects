## projects/develop/sn/Lab6/ub14.04/linux/security/mycatch/Kconfig
```kconfig
config SECURITY_MYCATCH
bool "Mycatch security module"
      	default y
help
      	Any help text here
```
